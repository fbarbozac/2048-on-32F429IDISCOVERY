# Keil uVision project 2048.uvprojx, settings and files
target 2048 (ARM-ADS)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 2048
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: HSE_VALUE=8000000 DATA_IN_ExtSDRAM STM32F429I_DISCOVERY
  c include: .\BSP\STM32F429I-Discovery;.\BSP\Components\l3gd20
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Manager
    ./: main.c Led.c Gyro.c
  group Game
    ./: Puzzle.c
  group BSP
    ./BSP/STM32F429I-Discovery/: stm32f429i_discovery_gyroscope.c stm32f429i_discovery.c
    ./BSP/Components/l3gd20/: l3gd20.c
software components: CMSIS:CORE 4.1.0, CMSIS:RTOS:Keil RTX 4.78.0, Board Support:Touchscreen 1.0.0, Board Support:emWin LCD 1.0.0, CMSIS Driver:I2C 2.02, CMSIS Driver:SPI 2.02, Device:STM32Cube Framework:Classic 1.1.0, Device:STM32Cube HAL:Common 1.1.0, Device:STM32Cube HAL:Cortex 1.1.0, Device:STM32Cube HAL:DMA 1.1.0, Device:STM32Cube HAL:DMA2D 1.1.0, Device:STM32Cube HAL:GPIO 1.1.0, Device:STM32Cube HAL:I2C 1.1.0, Device:STM32Cube HAL:LTDC 1.1.0, Device:STM32Cube HAL:PWR 1.1.0, Device:STM32Cube HAL:RCC 1.1.0, Device:STM32Cube HAL:SPI 1.1.0, Device:Startup 2.1.0, Graphics Display:STM32F429I-Discovery 1.0.0, Graphics:CORE 5.26.1, Graphics:Input Device:Touchscreen 5.26.1
